# Keil uVision project F3_Template.uvproj, settings and files
target F3_Template (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: F3_Template +hex
  c flags: Optim=1
  c include: .\Source\Libraries
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source
    ./Source/: main.c
  group Libraries
    ./Source/Libraries/: _delay_ms.s _delay_us.s
  group Startup
    ./Startup/: startup_stm32f30x.s system_stm32f30x.c
